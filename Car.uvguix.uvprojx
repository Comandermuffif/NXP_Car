# Keil uVision project Car.uvguix.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Car
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: main.c DC_Driver.c DC_Driver.h Servo_Driver.c Servo_Driver.h uart.c uart.h Camera_Driver.c Camera_Driver.h
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
